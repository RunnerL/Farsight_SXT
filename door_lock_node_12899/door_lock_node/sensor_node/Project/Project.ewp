# IAR project Project.ewp, settings and files
configuration STM320518-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; USE_STM320518_EVAL; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\; ..\Drivers\FreeModbus\modbus\include; ..\Drivers\FreeModbus\modbus\rtu; ..\Drivers\FreeModbus\port; ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\Utilities\STM32_EVAL\Common; ..\Utilities\STM32_EVAL\STM320518_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: testFreeMB_STM32F0.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f051x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration light sensor (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; USE_STM320518_EVAL; USE_DEFAULT_TIMEOUT_CALLBACK; LIGHT; xxBEEP; xxEEPROM; xxDEBUG
  ICCARM.CCIncludePath2: ..\; ..\Drivers\24CXX; ..\Drivers\FreeModbus\modbus\include; ..\Drivers\FreeModbus\modbus\rtu; ..\Drivers\FreeModbus\port; ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\Utilities\STM32_EVAL\Common; ..\Utilities\STM32_EVAL\STM320518_EVAL; light sensor\Src
configuration modbus sensor frame (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; USE_STM320518_EVAL; USE_DEFAULT_TIMEOUT_CALLBACK; xxBEEP; xxEEPROM; xxDEBUG
  ICCARM.CCIncludePath2: as above
  group CMSIS
    ../: system_stm32f0xx.c
  group Doc
    ./: readme.txt
  group Driver/FreeModbus/Modbus
    ../Drivers/FreeModbus/modbus/: mb.c
  group Driver/FreeModbus/Modbus/Functions
    ../Drivers/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Driver/FreeModbus/Modbus/include
    ../Drivers/FreeModbus/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group Driver/FreeModbus/Modbus/RTU
    ../Drivers/FreeModbus/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group Driver/FreeModbus/port
    ../Drivers/FreeModbus/port/: port.h portevent.c portserial.c porttimer.c
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group Lib
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../: FS_FIFO_V1.c Lock_Door_Opt.c main.c stm32f0xx_it.c
    ../Drivers/24CXX/: myiic.c
